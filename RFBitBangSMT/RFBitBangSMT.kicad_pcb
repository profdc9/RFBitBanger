# Repository profdc9/RFBitBanger (continued)

## KiCad design BitBangDisplay/BitBangDisplay.kicad_pcb

Parts:
C1: 10 nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2, C3, C4: 1 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C6: 22 uF; CP_Radial_D5.0mm_P2.50mm
C7, C8, C10, C11, C13, C14, C16, C17: 100 nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C9, C12: 100 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J1: Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
J2: Audio-Jack-3_2Switches; PJ-3240-35mm-stereo
J3, J7, J20, J21: Conn_01x01; 1pin
J4, J5, J6, J8, J9, J11, J12: Conn_01x01; SimpleHole
J10: Conn_01x20; Pin_Header_Straight_1x20_Pitch2.54mm
J13, J14, J15: KeyerJack; PJ-3240-35mm-stereo
J16: SPEAKER; TerminalBlock_bornier-2_P5.08mm
JP1, JP2: Jumper_NC_Dual; Pin_Header_Straight_1x03_Pitch2.54mm
JP3, JP4: LINE; Pin_Header_Straight_1x02_Pitch2.54mm
L1, L2, L3, L4: 100 uH; L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2
R1, R2: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R11, R20, R23, R29, R46, R47: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R9, R14, R16: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R7, R8, R12, R13, R17, R21, R24, R33: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R15, R18, R19: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22: 47R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_PUSH_6mm
U1: LCD1602ExtraPins; Pin_Header_Straight_1x16_Pitch2.54mm
U2: LM358; DIP-8_W7.62mm_Socket
U5: LCD1602ExtraPins; Pin_Header_Straight_1x20_Pitch2.54mm

Connections:
+5V: C7.1, C13.1, R4.1, R5.2, R6.2, R11.1, R12.2, R13.2, R24.2, R33.2, U1.2 (VDD), U2.8 (V+), U5.2 (VDD)
AVEE: U1.15 (A/VEE), U5.15 (A/VEE)
DB4: R29.2, U1.11 (DB4), U5.11 (DB4)
DB5: R3.2, U1.12 (DB5), U5.12 (DB5)
DB6: R47.2, U1.13 (DB6), U5.13 (DB6)
DB7: R46.2, U1.14 (DB7), U5.14 (DB7)
E: U1.6 (E), U5.6 (E)
GND: C1.2, C2.1, C3.1, C4.1, C7.2, C8.1, C10.1, C11.1, C13.2, C14.1, C16.1, C17.1, J2.3, J3.1, J7.1, J10.1, J10.2, J10.3, J10.4, J10.5, J10.6, J10.7, J10.8, J10.9, J10.10, J10.11, J10.12, J10.13, J10.14, J10.15, J10.16, J10.17, J10.18, J10.19, J10.20, J13.3, J15.3, J16.2, J20.1, J21.1, R14.2, R17.1, R21.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.1 (VSS), U2.4 (V-), U5.1 (VSS), U5.17
K: U1.16 (K), U5.16 (K)
MIC: R2.1, R20.2, U5.18
unnamed: C1.1, J2.1, J2.2, L4.1, R22.1
unnamed: C2.2, J13.2, L2.1
unnamed: C3.2, J13.1, L1.1
unnamed: C4.2, J15.1, L3.1
unnamed: C5.1, L3.2, R5.1
unnamed: C5.2, C6.2
unnamed: C6.1, R9.2
unnamed: C8.2, R11.2, R14.1, U2.3 (+), U2.5 (+)
unnamed: C9.1, JP3.2, R10.1, R15.2, U2.2 (-)
unnamed: C9.2, R15.1, R16.2, R17.2, U2.1
unnamed: C10.2, R6.1, R29.1, SW2.1
unnamed: C11.2, R3.1, R33.1, SW5.1
unnamed: C12.1, JP4.2, R18.1, R19.2, U2.6 (-)
unnamed: C12.2, R19.1, R20.1, R21.2, U2.7
unnamed: C14.2, R23.1, R24.1, SW1.1
unnamed: C16.2, R12.1, R47.1, SW3.1
unnamed: C17.2, R13.1, R46.1, SW4.1
unnamed: J1.1, J14.3
unnamed: J1.2, R7.2
unnamed: J1.3, R8.1
unnamed: J14.1, JP1.1, JP2.1
unnamed: J14.2, JP1.3, JP2.3
unnamed: J2.4, J16.1
unnamed: JP1.2, R7.1
unnamed: JP2.2, R8.2
unnamed: JP3.1, R9.1, R10.2
unnamed: JP4.1, R16.1, R18.2
unnamed: L1.2, R1.2
unnamed: L2.2, R2.2
PTT: R1.1, R4.2, U5.19
RS: R23.2, U1.4 (RS), U5.4 (RS)
RW: U1.5 (R/~W), U5.5 (R/~W)
SPKR: L4.2, R22.2, U5.20
VO: U1.3 (VO), U5.3 (VO)

Notes on the sheet:
BITBANGDISPLAY DRAFT V5 BY KW4TI
HD44780 DISPLAY AND PUSHBUTTONS

Board: 2 copper layers, 100.0 x 88.0 mm, 78 parts (51 on the bottom side), 44 nets.

## KiCad design LowPassFilter/LowPassFilter.kicad_pcb

Parts:
C1: C1; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C2: C2; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C3: C3; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C4: C4; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C5: C5; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C6: C6; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
J1: OUT; Pin_Header_Straight_1x04_Pitch2.54mm
J2: INP; Pin_Header_Straight_1x04_Pitch2.54mm
L1: L1; L_Toroid_Horizontal_D12.7mm_Compact
L2: L2; L_Toroid_Horizontal_D12.7mm_Compact
T1: DoubleWindingTransformer; DoubleWindingTransformerHorizontal

Connections:
GND: C1.1, C3.2, C5.2, J1.1, J1.2, J2.1, J2.2, T1.2
unnamed: C1.2, C2.1, C6.1, T1.3
unnamed: C2.2, L1.1
unnamed: C6.2, J2.4
unnamed: J2.3, T1.1, T1.4
unnamed: C3.1, C4.2, L1.2, L2.1
unnamed: C4.1, C5.1, J1.3, J1.4, L2.2

Board: 2 copper layers, 35.6 x 26.4 mm, 11 parts (0 on the bottom side), 7 nets.

## KiCad design MatchTester/MatchTester.kicad_pcb

Parts:
C1, C2, C3, C4: 10 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C6, C7: 10 nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D2, D4: 1N5711; D_DO-35_SOD27_P7.62mm_Horizontal
D5: LED; LED_D5.0mm
J1, J7, J8, J9, J10, J11, J12, J13, J14, J21, J22, J25, J26, J29, J30, J31: Conn_01x01; 1pin
J2, J3, J4, J20: Conn_Coaxial; bnc_90_1-1337543-0_pad_combo
J5: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
J33: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
JP1, JP2: PASS; Pin_Header_Straight_1x03_Pitch2.54mm
R1, R2, R3, R4, R9, R10, R11, R12, R13, R14: 100R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5, R6, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: POT; Potentiometer_Trimmer_Bourns_3296W

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, D5.1 (K), J1.1, J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), J5.2, J20.2 (Ext), J21.1, J22.1, J25.1, J26.1, J29.1, J33.3, R1.1, R2.1, R3.1, R4.1, R6.1, R8.1, R10.2, R12.2
unnamed: C2.1, J33.1, R5.1, R6.2
unnamed: C4.1, J33.2, R7.1, R8.2
unnamed: C6.1, JP2.1, R13.1, R14.1
unnamed: C6.2, D4.1 (K), R15.1, RV1.3
unnamed: C7.1, J5.1, RV1.1, RV1.2
unnamed: D2.2 (A), J11.1, J31.1, R3.2, R4.2
unnamed: D4.2 (A), R9.2, R10.1, R11.2, R12.1
unnamed: C5.1, D5.2 (A), R15.2
unnamed: J2.1 (In), JP1.2
unnamed: J3.1 (In), JP2.2
unnamed: J13.1, J20.1 (In)
unnamed: J4.1 (In), J9.1, J30.1
unnamed: JP1.1, JP2.3
unnamed: D1.2 (A), J7.1, R1.2, R2.2
unnamed: C1.1, D1.1 (K), R5.2
unnamed: C3.1, D2.1 (K), R7.2
unnamed: JP1.3, R9.1, R11.1, R13.2, R14.2

Notes on the sheet:
QRP Match Tester by Daniel Marks KW4TI CC-BY-SA 4.0

Board: 2 copper layers, 85.0 x 54.0 mm, 51 parts (0 on the bottom side), 18 nets.

## KiCad design PortableTerminal/PortableTerminal.kicad_pcb

Parts:
C1, C3, C8: 100 uF; CP_Radial_D5.0mm_P2.50mm
C2, C4, C7, C9, C10, C12, C13: 100 nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5, C6: 20 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C11: 10 nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D2, D3, D5, D6, D7: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D4: LED; LED_D3.0mm
J1: Barrel_Jack; BARREL_JACK
J2, J3, J5, J6: Conn_01x01; 1pin
J4: ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
J7, J8: Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
J9, J10: RCAJack; RCAConnectorCommon
J11: Conn_01x02; TerminalBlock_bornier-2_P5.08mm
J12: Conn_Coaxial; bnc_90_1-1337543-0_pad_combo
JP1, JP2: PWR; Pin_Header_Straight_1x02_Pitch2.54mm
JP3: Load; Pin_Header_Straight_1x02_Pitch2.54mm
P1: Mini-DIN_6pins_ver4; Connector_Mini-DIN_Female_6Pin_2rows
Q1, Q2: 2N3904; TO-92_Inline_Wide
R1, R2, R3, R16, R17, R19, R20, R21, R24, R29: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5, R7, R9, R11, R13, R15, R18: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 150R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R10, R12, R14, R25, R26: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22, R23: 100R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R27: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R28: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: POT; Potentiometer_Triwood_RM-065
SW1: SW_Push; SW_PUSH_6mm
T1: Common-Mode Choke; DoubleWindingTransformer
U1: LM7805_TO220; TO-220-3_Vertical
U2: ATMEGA328P-PU; DIP-28_W7.62mm_Socket
U3: LCD-016N002L; Pin_Header_Straight_1x16_Pitch2.54mm
U4: MicroSD_SPI_CD; GCT-MEM2055-00-190-01-A
U5: 74HC74; DIP-14_W7.62mm_Socket
Y1: Crystal; Crystal_HC49-U_Vertical

Connections:
+5V: C3.1, C4.1, C8.1, C10.1, D1.1 (K), D2.2 (A), D6.1 (K), J7.4, JP1.1, P1.4, R1.2, R2.2, R3.2, R6.1, R16.1, R17.2, R18.2, R20.2, RV1.1, U1.3 (VO), U2.7 (VCC), U2.20 (AVCC), U3.2 (VDD), U5.1 (Cd), U5.4 (Sd), U5.10 (Sd), U5.14 (VCC)
+12V: C1.1, C13.1, T1.2, U1.1 (VI)
CS: R14.2, U2.16 ((PCINT2/OC1B/~SS)PB2)
DB4: R28.1, R29.2, U2.23 ((PCINT8/ADC0)PC0), U3.11 (DB4)
DB5: U2.24 ((PCINT9/ADC1)PC1), U3.12 (DB5)
DB6: U2.25 ((PCINT10/ADC2)PC2), U3.13 (DB6)
DB7: U2.26 ((PCINT11/ADC3)PC3), U3.14 (DB7)
E: U2.14 ((PCINT0/CLKO/ICP1)PB0), U3.6 (E)
GND: C1.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C10.2, C11.2, C13.2, D4.1 (K), D5.2 (A), J2.1, J3.1, J4.6, J5.1, J6.1, J7.1, J8.1, J9.1 (SHIELD), J10.1 (SHIELD), J12.2 (Ext), JP2.2, P1.3, P1.7 (Shell), Q1.1 (E), Q2.1 (E), R5.1, R9.1, R11.1, R13.1, R15.1, R22.1, R23.1, R24.1, R29.1, RV1.3, SW1.1, T1.4, U1.2 (GND), U2.8 (GND), U2.22 (GND), U3.1 (VSS), U3.5 (R/~W), U4.6 (GND), U5.7 (GND)
MISO: J4.1, U2.18 ((PCINT4/MISO)PB4), U4.7 (DO)
MOSI: J4.4, R4.2, R10.2, U2.17 ((PCINT3/OC2A/MOSI)PB3)
MUTE: R19.2, R25.1, U2.11 ((PCINT21/OC0B/T1)PD5)
unnamed: C2.2, J8.4
unnamed: C5.2, U2.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.2
unnamed: C6.2, U2.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.1
unnamed: C9.1, R26.2
unnamed: D2.1 (K), D3.2 (A)
unnamed: D4.2 (A), R18.1
unnamed: D7.1 (K), R27.2
unnamed: C9.2, D7.2 (A), J12.1 (In), JP3.2
unnamed: J4.2, JP1.2
unnamed: J10.2 (PIN), R7.1, R8.1
unnamed: C12.1, J1.1, J11.1, T1.1
unnamed: C12.2, J1.2, J11.2, T1.3
unnamed: JP3.1, R22.2, R23.2
unnamed: Q1.2 (B), R19.1
unnamed: J9.2 (PIN), Q1.3 (C), R4.1, R5.2
unnamed: Q2.2 (B), R21.2
unnamed: Q2.3 (C), U3.16 (K)
unnamed: R6.2, U3.15 (A/VEE)
unnamed: R7.2, R21.1, U2.15 ((PCINT1/OC1A)PB1)
unnamed: R8.2, U2.13 ((PCINT23/AIN1)PD7)
unnamed: C7.1, D3.1 (K), R9.2, U4.4 (VDD)
unnamed: D5.1 (K), D6.2 (A), R24.2, R26.1, U5.3 (Cp)
unnamed: R25.2, U5.9 (Q)
unnamed: C11.1, R27.1, R28.2
unnamed: RV1.2, U3.3 (VO)
unnamed: JP2.1, R20.1, U2.6 ((PCINT20/XCK/T0)PD4)
unnamed: R14.1, R15.2, U4.2 (~CS)
unnamed: R10.1, R11.2, U4.3 (DI)
unnamed: R12.1, R13.2, U4.5 (SCLK)
unnamed: U5.2 (D), U5.6 (~Q)
unnamed: U5.5 (Q), U5.11 (Cp)
unnamed: U5.8 (~Q), U5.12 (D)
PS2CLK: P1.5, R16.2, U2.5 ((PCINT19/OC2B/INT1)PD3)
PS2DATA: P1.1, R17.1, U2.4 ((PCINT18/INT0)PD2)
RESET: C2.1, D1.2 (A), J4.5, R1.1, SW1.2, U2.1 ((PCINT14/~RESET)PC6)
RS: U2.12 ((PCINT22/OC0A/AIN0)PD6), U3.4 (RS), U5.13 (Cd)
RX: J8.3, U2.2 ((PCINT16/RXD)PD0)
SCK: J4.3, R12.2, U2.19 ((PCINT5/SCK)PB5)
SCL: J7.2, R3.1, U2.28 ((PCINT13/SCL/ADC5)PC5)
SDA: J7.3, R2.1, U2.27 ((PCINT12/SDA/ADC4)PC4)
TX: J8.2, U2.3 ((PCINT17/TXD)PD1)

Board: 2 copper layers, 79.0 x 75.0 mm, 76 parts (0 on the bottom side), 53 nets.

## Code that names these connections

File Code/RFBitBanger/RFBitBanger.ino (part):

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
volatile uint16_t adc_sample_1;

uint8_t mute = 0;

uint8_t srd_buffer[160];
scroll_readout_dat srd_buf = { 0, 1, 16, sizeof(srd_buffer), srd_buffer, 0 };
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    lcd.pollButtons();
    if (IS_SSB_PROTOCOL(ps.ssbs.protocol))
    {
      ssb_state_change(!digitalRead(PTT_PIN));
      //ssb_state_change(1);
  #ifdef SSB_DEBUG_REGISTERS
      ssb_debug();
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  {
    if (tone_state)
    {
      pinMode(BEEPOUT_PIN,INPUT);
      tone_state = 0;
    }
  }
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  {
    if ((!tone_state) || (freq != tone_last_freq))
    {
      if (!tone_state) pinMode(BEEPOUT_PIN,OUTPUT);  
      TCCR2B = 0;
      OCR2A = freq;
      OCR2B = vol;
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   TCCR2A = (1<<COM2B1) | (1 << WGM21) | (1 << WGM20); // fast pwm
   TCNT2 = 0;
   OCR2B = 0;
   pinMode(BEEPOUT_PIN,OUTPUT);
}

extern "C" {
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
  void muteaudio_set(uint8_t seton)
  {
    digitalWrite(MUTEAUDIO_PIN, seton != 0);
  }

  void transmit_set(uint8_t seton)
  {
    //OCR1A = seton != 0 ? TIMER1_COUNT_MAX : 0; 
    digitalWrite(TRANSMIT_PIN, seton != 0);
  }

  void set_clock_onoff_mask(uint8_t on_mask)
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  scroll_readout_initialize(&srd_buf);
  PSkey.begin();
  Serial.begin(DEFAULT_BAUDRATE);
  pinMode(PTT_PIN,INPUT);
  pinMode(MIC_PIN,INPUT);
  pinMode(AUDIOFILT_PIN,INPUT);
  pinMode(TRANSMIT_PIN,OUTPUT);
  pinMode(BACKLIGHT_PIN,OUTPUT);
  pinMode(MUTEAUDIO_PIN,OUTPUT);
  TONE_OFF();
  si5351.start();
  set_frequency_receive();
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  if (current_check_time == kc->last_check_time) return;
  kc->last_check_time = current_check_time;

  uint8_t read_dit = (lcd.readUnBounced(1)) || (!digitalRead(PTT_PIN));
  uint8_t read_dah = (adc_sample_1 < KEYDOWN_SAMPLE_THRESHOLD);

  if (rc.cw_iambic && rc.cw_iambic_switch)
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
## Commit log

2021-10-07 Changed audio amplification
2021-10-09 Fixed stupid disconnected line, added multiple output transistors
2021-10-09 Changed to using regular HD44780 6-pin display
2021-10-10 Changed wiring around, started documentation
2021-10-15 Added SI5351A and code snippets
2021-10-17 Worked on DSP algorithm
2021-10-23 JLCPCB order 2021-10-22
2021-10-24 Corrected mistake in Docs
2021-10-30 Working demodulation without AGC
2021-10-31 Working auto level adjustment
2021-11-01 Working AGC, good test of frame decode
2021-11-02 Added lag/lead detection to resync word
2021-11-04 Before changing to 74HC86
2021-11-05 Advanced/Delay improvements
2021-11-07 Before swapping MUTEAUDIO and TRANSMIT
2021-11-09 Before rearrange audio section
2021-11-10 Added RF current sensor and Bridge Board
2021-11-11 Rearranged current sensor
2021-11-12 Added Portable Terminal
2021-11-17 Added CW decode
2021-11-20 Cleaned up layout
2021-11-22 cwmod
2021-12-13 Completely remade board with common base input
2021-12-22 A few minor tweaks to layout
2021-12-24 Started RFBitBanger code project
2021-12-26 Added bias potentiometer and user interface
2021-12-26 Added UI
2021-12-26 Before changing back to HPF
2021-12-27 Added common mode choke, put back LPF
2021-12-28 Made 3 crystals instead of 2
2021-12-28 Added removal of solder mask for heatsinking
2021-12-31 Added overvoltage zener and extra key inputs
2022-01-02 Moved labels
2022-01-02 Fixed overcommited MOSI pin
2022-01-03 Added frequency counter and power measurement circuitry to PortableTerminal
2022-01-03 Added common mode choke to PortableTerminal
2022-01-04 Added README.md
2022-01-09 Lots of changes...
2022-01-11 Implemented timers, fixed beep audio, fixed key shaping
2022-01-12 Rearranged parts for better layout
2022-01-16 Changed DSP to higher audible frequencies
2022-01-20 Added Display Board on Top
2022-01-22 Before trying to put everything onto a single line
2022-01-23 Changed external connector for single 20 pin or ribbon cable
2022-01-24 JLCPCB order 2022-01-24
2022-01-28 Before changing si5351 code
2022-02-04 Before adding SI5351 header
2022-02-04 Added connector for SI5351A board
2022-02-26 Added fifth button
2022-03-01 Added code for fifth button
2022-03-15 Added edit text code
2022-04-23 Added extra row of ground pins for 40 pin connector
2022-12-29 UI Changes
2022-12-29 Changed around for external filter PCB
2022-12-30 BandPassFilter now has six filter boards on it
2023-01-02 UI changes and transmit added
2023-01-02 forgot common.h
2023-01-03 Working CW decode
2023-01-04 Working SCAMP receive
2023-01-05 Working RTTY
2023-01-05 Changed SCAMP mode protocol codes, added simple configuration method
2023-01-06 Added simple keyer mode
2023-01-07 Working configuration, fixed bugs
2023-01-08 Added Xtal Calibration Mode
2023-01-09 Reorganized pointers to different protocols
2023-01-10 Revised SCAMP digital mode descrption
2023-01-11 Fixed SCAMP pointers
2023-01-11 Fixed many scamp issues
2023-01-12 Added EXT control feature
2023-01-12 Working analog comparator
2023-01-12 Added band change warning
2023-01-17 Fixed external control mode
2023-01-17 Changed bitbang display values
2023-01-17 Added New Documentation
2023-01-18 Modified BandPass Filter, Documentation
2023-01-23 Added RIT and CW decode options
2023-01-23 Changed some component values
2023-01-23 Increased size of heatsink pad
2023-01-23 Updated Manual and Schematics
2023-02-02 Modified FSK SLOW mode, added section back about +- filters
2023-02-03 Modified SCAMP FSK FAST
2023-02-04 Added circuit simulations
2023-02-05 Added single SerialResonantFilter
2023-02-05 Converted all Kicad projects to version 6.0.10
2023-02-13 Added rescue
2023-02-13 Added RFBitBangerNano
2023-02-13 Added RFBitBangerNano gerbers
2023-02-16 Changes to RTTY
2023-02-16 A first draft of iambic mode
2023-02-16 Added experimental extra averaging to improve SNR of ADC
2023-02-17 Added case for RFBitBanger
2023-02-17 Did some modification to ADC to not use triggered mode
2023-02-18 Added insets to standoffs
2023-03-05 Made capacitors on board dual footprint
2023-03-05 Changed size of text on capacitor footprint
2023-03-05 Moved labels to side
2023-03-06 Added two dual capacitor footprints to RFBitBanger
2023-03-30 Added parametric model of air core coil forms
2023-04-05 Moved 1 digit on BitBangDisplay
2023-04-05 Fixed iambic mode b
2023-04-06 Added reinforcement to case standoffs
2023-04-21 Added simple serial support
2023-04-21 Not so simple serial support
2023-04-21 Redid iambic support
2023-04-21 Added output word wrap, changed to 2400 baud
2023-04-21 changed the return timing
2023-04-22 Added provisional iambic paddle state machine documentation
2023-05-06 Added pictures
2023-05-18 Widened gap for SMT capacitors to 1206
2023-05-19 Another go at the iambic support
2023-05-26 First Commit SMT version
2023-05-27 Tested with JLCPCB but not fabricated
2023-05-28 Minor fixes to SMT
2023-05-29 Some more minor SMT fixed
2023-05-29 Added Low Pass Filter
2023-05-31 Try again with iambic
2023-05-31 JLCPCB order
2023-06-07 Minor tweaks to iambic
2023-06-07 Changed latching
2023-06-07 A few minor fixes to SMT
2023-06-09 Added SCAMP FSK VERY SLOW mode
2023-06-11 Added heatsink pad for Q16 RFBitBangSMT
2023-06-12 Added very slow mode and computation of 2500 Hz SNR
2023-06-12 Working frequency estimation
2023-06-12 offset progress
2023-06-12 First SSB
2023-06-13 a working ssb signal!
2023-06-13 So far pretty much working ssb!
2023-06-13 A few more fixes
2023-06-13 Removed SMT Q8
2023-06-14 Added CW and SSB offsets
2023-06-21 Added ssb transmit indicator
2023-06-21 Still trying to figure out ssb offset
2023-06-23 Updated documentation
2023-08-04 Fixed problems with manual, added filters
2023-08-05 Added Serial Resonant Filter multi PCB
2023-08-07 Aligned mounting holes to new display for BitBangDisplay
2023-08-07 Swapped UART and PADDLE jacks
2023-08-18 Manufactured RFBitBangSMT
2023-08-21 Made six panel version of SerialResonantFilterSMT
2023-08-25 Fixed SSB/keyboard problem, ui check
2023-08-25 Changed threshold
2023-08-26 Second attempt at keyboard fix
2023-08-28 Added latest version of SCAMP proposal and to manual
2023-09-12 Moved all mode offsets to USB, changed SCAMP prefix code
2023-09-12 Added end of transmission code
2023-09-13 Forgot to delete redundant lines
2023-09-13 Revised SCAMP mode 0.9
2023-09-29 Scamp version 0.91
2023-10-08 Swapped multisynth and PLL integer dividers
2023-10-09 Simplified SSB
2023-10-14 Made input/output buffers bigger, fixed scamp repeat bug
2023-10-15 Added section about tuning filter to manual
2023-10-28 Added TCXO option to RFBitBanger SMT
2023-10-29 Fixed serial bug
2023-10-29 Added cut slots around crystal
2023-10-30 Batch 2 test PCBs
2023-11-11 SCAMP fixed TX timing
2023-11-11 Moved PLLBoard to its own project
2023-11-12 Issue #4 - Enabling non-Arduino builds for core SCAMP encode/decode
2023-11-12 Issue #4 - Non-Arduino build
2023-11-18 Added portability and fixed some compilation errors
2023-12-03 Added TCXO to documentation, finalized JLCPCB for batch 2
2023-12-03 Add link to presentation
2023-12-13 Added picture of SMT version
2024-11-25 Fixed minor issue with sending end transmission
