# Repository profdc9/RFBitBanger

File README.md:

# RFBitBanger
The RFBitBanger is an off-the-grid QRP radio.  It is not just designed to be used off the grid, it is designed to be assembled and maintained off-the-grid.  Most radios require specialized parts that would be difficult to obtain in an extreme parts shortage or in remote places.  This radio is designed to be assembled and maintained using the most common jellybean components that might be in a hobbyist junkpile.  It will mainly support low bandwidth/digital modes to make the most of limited power.  

A presentation presented at the 2023 QSO Today conference on the RFBitBanger can be viewed on Youtube [here](https://www.youtube.com/watch?v=Fbgs_4QsKnE).

Design goals:

* A single band double-sideband radio, with the band changed by pluggable external filters on 20 m to 80 m.  A double-balanced ring mixer is used to provide good rejection of strong stations while not requiring any custom ICs such as SA612 or FST3253.  The mixer has strong drive to reduce nonlinearity.
* Can be assembled and operated by a properly licensed individual that may not have a great deal of electronics experience or experience at making HF contacts.  The radio is made from readily available through-hole parts which are widely available and have multiple vendor alternatives.  
* The parts needed are very common so that cheap spare parts can be stockpiled or scrounged from other equipment so that the radio may be more easily maintained in off-grid conditions.  The includes ATMEGA328P/Arduino Nano, LM358 op-amp, LM386 audio amplifier, 2N7000 MOSFETs, 2N3904 NPN transistor, SS8550 PNP transistor, and a HD44780 display.  It can use a SI5351A frequency synthesizer IC soldered to the board, or a plug-in SI5351A developmnet module.  There is a MS5351 workalike for this IC as well.  Ferrite cores are needed for transformers/chokes which can be easily bought (FT50-43) or scrounged as EMI suppression beads from cables.
* The radio has a novel digital mode called SCAMP, implemented on a ATMEGA328P (Arduino processor) which performs coherent FSK demodulation and forward error correction to achieve excellent performance in weak signal conditions.  No PC is required for this digital mode; it is implemented all on the Arduino.  The mode is designed to be simple to set up to make it easy to initiate a contact.
* It has a 50 ohm output and can use a simple quarter wave wire as an antenna.  A built-in RF ammeter with LED helps one adjust the length of the antenna for maximum radiation.
* The output power amplifier consists of 3 2N7000 transistors driven by a fourth 2N7000 transistor.  2N7000 transistors can be found generically for $0.03 each.  The output power stage is a class E amplifier with 3.5 to 5.0 W output based on serial resonance filters.  The best performance is obtained by using NP0/C0G capacitors and T50-6 core inductors, however, high voltage ceramic disc capacitors and air-core inductors can be used as substitutes with reduced performance.  The serial resonance filter is on a pluggable module that is replaced for each band.  BS170 transistors may be substituted for 2N7000 transistors easily as these have the reverse pinout to the 2N7000.
* It has PCBs available for the transceiver, but it could also be built on perfboard or using point-to-point wiring.  The PCB, however, is likely to be better performing.  There are also PCBs available for the filters.
* A jumper allows the amplifier board to be bypassed on receive to achieve MF and HF coverage.  The DSB receiver can be used with limitations as a receiver for the AM broadcast band and AM broadcast shortwave bands.
* It has an audio speaker output based on the LM386 IC.
* A second display board breaks out the display, and optional inputs for a microphone, a straight or iambic key, and a headphone/speaker jack.  
* A PS/2 keyboard is supported for full operation of the transceiver, including message entry, frequency selection, and data mode selection.
* There are five buttons corresponding to four arrow keys and an enter key.  Alphanumeric messages may be entered this way if necessary.
* There is a full complement of support for CW, including keyclick elimination on transmit, a built-in CW decoder, a CW encoder, and straight and iambic key support.
* RTTY 45/170 is supported as a mode for transmit and reception.
* Uses a common 2X16 HD44780-based LCD display.
* Supports SSB transmission based on the same method of the uSDX of frequency tracking and envelope recovery.
* Includes a 3d printable case, a 3d printable iambic key, and 3d printable coil forms for air core inductors.
* The PCBs are licensed under the CC-BY-SA 4.0 open source license, and the source code is licensed under the zlib open source license.

The RFBitBanger folder is the schematic and PCB for the radio itself.  The MatchTest is a PCB that has a directional coupler for measuring forward/reverse power as well as a reflection bridge to help match antenna impedance.  The Code folder contains the current RFBitBanger code.  The CAD directory contains FreeCAD parametric models and STL files. The Docs directory contains a guide to the transceiver and the details of the SCAMP digital mode implementation.

This design was started after a discuss on the [Collapse OS](http://collapseos.org) mailing list about hardware is maintainable even without access to parts suppliers, for example Digikey/Mouser, etc. or even Amazon.  Projects such as [civboot](https://github.com/civboot/civboot) seek to provide a means of resurrecting technology and infrastructure after a catastrophic event.  This design is to provide a means of communication if other forms of communications become unavailable, especially in rural areas or urban environments with compromised infrastructure.

Any comments to profdc9 AT gmail.com.

## KiCad design RFBitBangSMT/RFBitBangSMT.kicad_pcb

Parts:
C1, C2, C10, C11, C16, C17, C36, C37, C41, C42, C44, C57, C58, C59, C61, C64, C65, C70: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C3, C53: 1000 uF; CP_Radial_D8.0mm_P3.50mm
C4, C5, C66, C69: 100 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1790
C6: 100 uF; CP_Radial_D5.0mm_P2.50mm
C7, C62, C67, C68: 1 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C46653
C8, C9: 12 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1792
C15, C63: 10 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C18, C60, C71: NC; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19: 220 uF; CP_Radial_D7.5mm_P2.50mm
C34: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: 1N4745A; D_DO-41_SOD81_P7.62mm_Horizontal
D2: 1N4148; D_SOD-123; LCSC C81598
D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
DS1: LCD1602A; WC1602A
J1: POWER; TerminalBlock_bornier-2_P5.08mm
J2: Barrel_Jack; BARREL_JACK
J3, J4, J6, J7, J13, J20, J21: Conn_01x01; 1pin
J5: Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
J8, J11, J19: AudioJack2_Dual_Ground_Switch; PJ-3240-35mm-stereo
J9: ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
J14, J15, J16: Conn_01x01; Pin_Header_Straight_1x01_Pitch2.54mm
J22: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J23: Conn_01x01; MountingHole_3.2mm_M3
JP3: 5VDC; Pin_Header_Straight_1x02_Pitch2.54mm
JP6, JP9: HIGAIN; PinHeader_1x02_P2.54mm_Vertical
L1, L2: 10 uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C1046
L7, L8, L12: 100 uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C68035
L10: 100 uH; L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2; LCSC C1017
P1: Mini-DIN_6pins_ver4; MiniDin 6
Q4, Q14: MMBT3904; SOT-23; LCSC C20526
R1, R3, R29, R30, R40, R45, R46, R47, R64, R70, R72, R82, R84: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R2: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17408
R4, R6, R12, R13, R33, R75, R77, R85, R86: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R10, R31, R32, R34, R69, R76, R83: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C149504
R11: 47R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17714
R42, R43, R44, R78: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17673
R79: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17560
R80, R81: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17710
RV1: 10k; Potentiometer_Big_Small_Combined
RV3: 10k; Potentiometer_Triwood_RM-065
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_PUSH_6mm
T4: Common-Mode Choke; DoubleWindingTransformer
U1: ATmega328P-A; TQFP-32_7x7mm_P0.8mm; LCSC C14877
U2: LM78M05_TO252; TO-252-2; LCSC C58069
U3: LM386; SOP-8_3.9x4.9mm_P1.27mm; LCSC C383071
U5: LM358; SOP-8_3.9x4.9mm_P1.27mm; LCSC C7950
Y1: 16 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering; LCSC C13738

Connections:
+5V: C1.1, C6.1, C36.2, C42.1, C59.1, C65.2, C70.2, D2.1 (K), DS1.2 (VDD), JP3.2, P1.4, R1.1, R2.2, R4.1, R6.2, R12.2, R13.2, R33.2, R42.1, R45.1, R64.2, R70.1, R75.2, R82.1, RV3.3, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.3 (VO), U5.8 (V+); also elsewhere on the board
+12V: C3.1, C37.1, C44.2, C53.1, D1.1 (K), T4.2, U2.1 (VI), U3.6 (V+); also elsewhere on the board
AUDIO: R32.1; also elsewhere on the board
AUDIOFILT: J14.1, U1.23 (PC0); also elsewhere on the board
BEEPOUT: R10.1, U1.1 (PD3)
DB4: DS1.11 (D4), R29.2, U1.9 (PD5)
DB5: DS1.12 (D5), R3.2, U1.10 (PD6)
DB6: DS1.13 (D6), R47.2, U1.11 (PD7)
DB7: DS1.14 (D7), R46.2, U1.12 (PB0)
E: DS1.6 (E), U1.25 (PC2)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C15.2, C16.1, C17.1, C18.2, C36.1, C37.2, C41.2, C42.2, C44.1, C53.2, C57.2, C59.2, C60.1, C61.1, C62.1, C64.1, C65.1, C67.1, C68.1, C70.1, D1.2 (A), D3.1 (K), DS1.1 (VSS), DS1.5 (R/W), J3.1, J4.1, J5.1, J6.1, J7.1, J8.G, J9.6, J11.G, J15.1, J16.1, J19.G, J20.1, J21.1, J22.2, P1.3, P1.7 (Shell), Q4.2 (E), Q14.2 (E), R44.2, R77.2, R85.2, RV1.3, RV3.1, SW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, T4.4, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.2 (GND), U3.3 (+), U3.4 (Gnd), U5.4 (V-); also elsewhere on the board
MICPADDLE: C7.2, R81.1, R84.1, U1.24 (PC1)
MISO: J9.1, P1.1, R70.2, U1.16 (PB4)
MOSI: J9.4, R72.2, U1.15 (PB3)
MUTEAUDIO: R30.2, U1.2 (PD4)
unnamed: C2.2, J5.4
unnamed: C4.1, J5.3, L1.1
unnamed: C5.1, J5.2, L2.1
unnamed: C8.2, U1.7 (XTAL1/PB6), Y1.3
unnamed: C9.2, U1.8 (XTAL2/PB7), Y1.1
unnamed: C10.2, R6.1, R29.1, SW2.1
unnamed: C11.2, R3.1, R33.1, SW5.1
unnamed: C15.1, U3.7
unnamed: C16.2, R12.1, R47.1, SW3.1
unnamed: C17.2, R13.1, R46.1, SW4.1
unnamed: C18.1, Q4.3 (C), R32.2, R34.1
unnamed: C19.1, C41.1, L10.2, R11.1
unnamed: C34.1, R31.2, R34.2
unnamed: C34.2, RV1.1
unnamed: C57.1, U1.20 (AREF)
unnamed: C58.1, J1.1, J2.2, T4.3
unnamed: C58.2, J1.2, J2.1, T4.1
unnamed: C60.2, R10.2, R31.1
unnamed: C61.2, R40.1, R75.1, SW6.1
unnamed: C62.2, J11.T1, L7.2, R42.2
unnamed: C63.1, L7.1
unnamed: C63.2, R43.1
unnamed: C64.2, R44.1, R45.2, U5.3 (+), U5.5 (+)
unnamed: C66.1, JP6.1, R69.1, R76.2, U5.2 (-)
unnamed: C66.2, R76.1, R77.1, R78.1, U5.1
unnamed: C67.2, J19.T1, L8.2
unnamed: C68.2, J19.S1, L12.2
unnamed: C69.1, JP9.1, R79.1, R83.2, U5.6 (-)
unnamed: C69.2, R83.1, R84.2, R85.1, U5.7
unnamed: C71.1, U3.1
unnamed: C71.2, U3.8
unnamed: D3.2 (A), R4.2
unnamed: DS1.3 (VO), RV3.2
unnamed: DS1.15 (LED(+)), R2.1
unnamed: DS1.16 (LED(-)), Q14.3 (C)
unnamed: J9.2, JP3.1
unnamed: JP6.2, R43.2, R69.2
unnamed: JP9.2, R78.2, R79.2
unnamed: L8.1, R80.2
unnamed: L10.1, R11.2, U3.5
unnamed: L12.1, R81.2
unnamed: Q4.1 (B), R30.1
unnamed: Q14.1 (B), R72.1
unnamed: R80.1, R82.2, R86.1
unnamed: RV1.2, U3.2 (-)
PS2CLK: P1.5, R64.1, U1.32 (PD2)
RESET: C2.1, D2.2 (A), J9.5, R1.2, SW1.2, U1.29 (~RESET/PC6)
RS: DS1.4 (RS), R40.2, U1.26 (PC3)
RXD: L2.2, U1.30 (PD0)
SCK: J9.3, R86.2, U1.17 (PB5)
SCL: U1.28 (PC5); also elsewhere on the board
SDA: U1.27 (PC4); also elsewhere on the board
SPKR: C19.2, J8.S1, J8.T1, J22.1
TRANSMIT: U1.13 (PB1); also elsewhere on the board
TUNING: U1.14 (PB2); also elsewhere on the board
TXD: L1.2, U1.31 (PD1)

Notes on the sheet:
POWER SUPPLY AND FILTER
PS/2 KEYBOARD CONNECTOR
MICROPHONE/PADDLE
AUDIO AMPLIFIER OUTPUT
RFBitBangSMT 20m to 80m BAND DRAFT V5 BY KW4TI
HD44780 DISPLAY AND PUSHBUTTONS

Parts:
C12: 10 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C13, C20, C24, C25, C27, C38, C46, C47, C51, C54, C55, C56, C72: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C14, C29, C39: 1 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C28323
C21, C22, C28, C48: 100 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1790
C23, C26, C30, C33: 10 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1710
C31: 4.7 uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1779
C32, C43: NC; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C35: 220 pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C107145
C40: 100 uF; CP_Radial_D5.0mm_P2.50mm
C45: 330 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1740
C49: 22 uF; CP_Radial_D5.0mm_P2.50mm
C50, C52: 10 uF; CP_Radial_D5.0mm_P2.50mm
D4, D5, D8: 1N4007; D_SMA_Handsoldering; LCSC C95872
D6: 1N4757; D_DO-41_SOD81_P7.62mm_Horizontal
D9, D10, D11, D12, D13, D14, D15, D17, D18: 1N4148; D_SOD-123; LCSC C81598
D16, D19: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
H1, H2, H3, H4, H5: MountingHole; CutSlot
J10: si5351mod; Pin_Header_Straight_1x07_Pitch2.54mm
J12: Conn_Coaxial; bnc_90_1-1337543-0_pad_combo
J17: Filt1; Pin_Header_Straight_1x04_Pitch2.54mm
J18: Filt2; Pin_Header_Straight_1x04_Pitch2.54mm
J25: Conn_01x01; PinHeader_1x01_P2.00mm_Vertical
JP1: QSK; Pin_Header_Straight_1x02_Pitch2.54mm
JP2: Sample; Pin_Header_Straight_1x02_Pitch2.54mm
JP4: BYPASS; Pin_Header_Straight_1x02_Pitch2.54mm
JP5: JREF1; Pin_Header_Straight_1x03_Pitch2.54mm
JP7: JVAL1; Pin_Header_Straight_1x03_Pitch2.54mm
JP8: Shutdown; Pin_Header_Straight_1x02_Pitch2.54mm
JP10: BTP; PinHeader_1x02_P2.54mm_Vertical
JP11: TCXO; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L3, L5, L11: 100 uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C68035
L4: 100 uH; SmallVerticalToroid
L6: 22 uH; SmallVerticalToroid
L9: 22 uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C32375
Q1, Q2, Q10, Q11, Q12: MMBT3904; SOT-23; LCSC C20526
Q3, Q6, Q7, Q9: 2N7000; TO-92_Inline_Wide
Q5: NC; TO-92_Inline_Wide
Q8: SS8550; TO-92_Inline_Wide
Q13: SS8550; SOT-23; LCSC C8542
Q15: NC; TO-220-3_Vertical
R5, R21, R25, R28: 50R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17720
R7, R24, R58, R62, R73: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R8, R14, R17, R19: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17710
R9, R55, R61: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C149504
R15, R52: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17713
R16, R66: 470k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17709
R18, R22, R26, R27, R35, R36, R37, R48, R54, R59, R65, R68, R71: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R20, R63: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17408
R23: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17556
R38: 2R2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17521
R39, R60: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17560
R41: 150R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R49, R50: 47R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17714
R51, R74: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17477
R53, R56, R67: NC; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R57: 3k3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C26010
RLY1: DPDTRelay; G2VRelay
RV2: 10k; Potentiometer_Big_Small_Combined
RV4: 2k; Potentiometer_Trimmer_Bourns_3296W
T1, T2: Trifilar; TripleWindingTransformerRef
T3: Current; SamplingTransformer
U4: LM358; SOP-8_3.9x4.9mm_P1.27mm; LCSC C7950
U6: SI5351A; MSOP-10_3x3mm_Pitch0.5mm; LCSC C1509083
Y2, Y4, Y5: 7.X MHz; Crystal_HC49-U_Vertical
Y3: 25 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006

Connections:
+5V: C25.1, D10.2 (A), J10.7, Q11.3 (C), R18.1, R61.1, RV4.1, U4.8 (V+); also elsewhere on the board
+12V: L4.1; also elsewhere on the board
AMPOUT: C32.1, D6.1 (K), L6.2, Q3.3 (D), Q5.3 (D), Q6.3 (D), Q7.3 (D), Q15.2 (D), R74.1, R74.2, RLY1.2 (Pole)
AUDIO: C28.2, C35.2, R23.1, R24.2, R36.2, U4.7; also elsewhere on the board
AUDIOFILT: C33.1, R24.1; also elsewhere on the board
GND: C12.2, C13.2, C20.1, C22.2, C24.1, C25.2, C32.2, C33.2, C38.2, C40.2, C43.2, C46.1, C47.1, C50.2, C52.2, C55.1, C72.1, D4.2 (A), D5.2 (A), D6.2 (A), D8.2 (A), D17.2 (A), J10.6, J12.2 (Ext), J17.1, J17.2, J18.1, J18.2, J25.1, JP8.2, JP10.1, Q3.1 (S), Q5.1 (S), Q6.1 (S), Q7.1 (S), Q12.2 (E), Q15.3 (S), R16.1, R17.1, R19.2, R21.1, R22.2, R28.2, R36.1, R37.1, R41.1, R56.2, R58.2, R59.1, R66.2, R67.1, RLY1.5 (Coil), RV4.3, T1.1, T1.4, T1.5, T2.2, T3.3 (SAMPLE), U4.4 (V-), U6.8 (GND), Y3.2; also elsewhere on the board
IF: C27.2, L5.1, T2.4, T2.5
unnamed: C12.1, C13.1, L3.1, R9.1
unnamed: C14.1, C20.2, C24.2, C29.1, L6.1, Q8.3 (C), Q9.3 (D), R52.1, R53.2
unnamed: C14.2, C29.2, Q8.2 (B), R8.1, R14.1
unnamed: C21.1, C22.1, Q2.2 (E), R17.2, R68.2
unnamed: C21.2, JP8.1, Q2.1 (B), R15.2, R16.2, Y2.1, Y4.1, Y5.1
unnamed: C23.1, R51.2
unnamed: C23.2, D17.1 (K), Q3.2 (G), Q5.2 (G), Q6.2 (G), Q7.2 (G), Q15.1 (G), R53.1, R67.2, R73.2
unnamed: C26.1, RLY1.4 (NO)
unnamed: C26.2, J17.3, JP4.1
unnamed: C27.1, R21.2
unnamed: C28.1, C35.1, R26.1, U4.6 (-)
unnamed: C30.1, R5.1
unnamed: C30.2, T1.2
unnamed: C31.1, JP1.2
unnamed: C31.2, C46.2, C55.2, D19.2 (A), L4.2, Q2.3 (C), Q8.1 (E), Q10.3 (C), Q13.2 (E), R8.2, R15.1, R55.1
unnamed: C38.1, L11.1, R73.1
unnamed: C39.1, R37.2, RV2.3, U4.1
unnamed: C39.2, R27.2
unnamed: C40.1, C45.1, R18.2, R19.1, R62.1, R63.2, U4.5 (+)
unnamed: C43.1, C49.2, L5.2
unnamed: C45.2, R23.2, R26.2, R27.1
unnamed: C47.2, D14.1 (K), JP11.2 (B), R35.2, R48.2, U6.1 (Vdd), U6.7 (VDDO)
unnamed: C48.1, Y2.2, Y4.2, Y5.2
unnamed: C48.2, D4.1 (K), D5.1 (K), R9.2
unnamed: C49.1, Q1.2 (E), R22.1
unnamed: C50.1, Q1.1 (B), R58.1, R60.2
unnamed: C51.1, C56.2, JP5.2
unnamed: C51.2, R54.2
unnamed: C52.1, Q11.1 (B), R61.2
unnamed: C54.1, Q1.3 (C), R57.2
unnamed: C54.2, R62.2, U4.3 (+)
unnamed: C56.1, R20.2
unnamed: C72.2, JP11.1 (A), Y3.4
unnamed: D10.1 (K), D14.2 (A)
unnamed: D11.1 (K), D13.2 (A), T2.6
unnamed: D9.1 (K), D11.2 (A), T1.3
unnamed: D9.2 (A), D12.1 (K), T2.3
unnamed: D12.2 (A), D13.1 (K), T1.6
unnamed: D15.1 (K), R38.2
unnamed: D15.2 (A), JP1.1, R39.2
unnamed: D16.1 (K), R28.1
unnamed: D16.2 (A), T3.4 (SAMPLE)
unnamed: D18.1 (K), Q12.3 (C), R38.1, R71.1
unnamed: D18.2 (A), R14.2
unnamed: D19.1 (K), R71.2
unnamed: J10.1, R49.1, U6.10 (CLK0)
unnamed: J10.2, R50.1, U6.9 (CLK1)
unnamed: J12.1 (In), JP2.1, T3.2 (RF)
unnamed: J17.4, JP7.1
unnamed: J18.3, J18.4, JP2.2, JP4.2, JP7.3, T3.1 (RF)
unnamed: JP7.2, RLY1.7 (NC)
unnamed: JP10.2, L11.2, RV4.2
unnamed: L3.2, R7.1
unnamed: L9.2, R65.2
unnamed: Q9.1 (S), R41.2, R51.1
unnamed: Q9.2 (G), R20.1, R52.2, R66.1
unnamed: Q10.1 (B), R54.1, R55.2, R56.1
unnamed: Q10.2 (E), R5.2, R59.2
unnamed: Q11.2 (E), R57.1, R60.1
unnamed: Q12.1 (B), R65.1
unnamed: Q13.1 (B), R39.1
unnamed: R25.2, T2.1
unnamed: R63.1, RV2.1, RV2.2, U4.2 (-)
unnamed: U6.2 (XA), Y3.3
unnamed: U6.3 (XB), Y3.1
PLLOSC: JP5.1, R49.2, R50.2
RF: R25.1, RLY1.6 (Pole)
SCL: J10.4, R35.1, U6.4 (SCL); also elsewhere on the board
SDA: J10.5, R48.1, U6.5 (SDA); also elsewhere on the board
TRANSMIT: L9.1; also elsewhere on the board
TUNING: R7.2; also elsewhere on the board
TXRELAY: D8.1 (K), Q13.3 (C), RLY1.1 (Coil)
XOSC: JP5.3, R68.1

Notes on the sheet:
AUDIO AMPLIFICATION
ARDUINO OOK/FSK TRANSMISSION RECEPTION 40/80 METER BAND DRAFT V3 BY KW4TI
3 TURNS
ALTERNATE SI5351A OSCILLATOR
3 TURNS
COLPITTS CRYSTAL OSCILLATOR
RF AMPLIFIER
BALANCED RING MIXER

Board: 2 copper layers, 152.0 x 88.0 mm, 271 parts (0 on the bottom side), 142 nets.

## KiCad design SerialResonantFilterSMT/SerialResonantFilter.kicad_pcb

Parts:
C1, C5, C29, C32: 330 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C527285
C2: 1000 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C527339
C3, C9, C16: C3; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4, C6, C37, C40, C57, C58: 1000 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7, C12, C19: C7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8, C13, C30, C33: 150 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C577189
C10, C31, C34, C51, C52: 470 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C527302
C11, C14: 470 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C15, C20, C35, C38: 680 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C541497
C17: 2200 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C527261
C18, C21, C36, C39: 2200 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C22: C1; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C23: C3; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C24: C2; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C25: C4; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C26: C7; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C27: C5; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C28: C6; C_Disc_D5.0mm_W2.5mm_P5.00mm_Dual
C41, C44, C46, C47: 100 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C42, C45: 47 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C43, C48: 220 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C49, C50: 33 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C53, C54: 68 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C55, C56: 1500 pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J1: OUT; Pin_Header_Straight_1x04_Pitch2.54mm
J2: INP; Pin_Header_Straight_1x04_Pitch2.54mm
J3, J5, J7: INP; PinSocket_1x04_P2.54mm_Vertical
J4, J6, J8: OUT; PinSocket_1x04_P2.54mm_Vertical
L1: 0.39 uH; L_Toroid_Horizontal_D12.7mm_Compact
L2: 0.77 uH; L_Toroid_Horizontal_D12.7mm_Compact
L3: 0.36 uH; L_Toroid_Horizontal_D12.7mm_Compact
L4: 0.18 uH; L_Toroid_Horizontal_D12.7mm_Compact
L5: 1.45 uH; L_Toroid_Horizontal_D12.7mm_Compact
L6: 0.68 uH; L_Toroid_Horizontal_D12.7mm_Compact
L7: L2; L_Toroid_Horizontal_D12.7mm_Compact
L8: L3; L_Toroid_Horizontal_D12.7mm_Compact

Connections:
GND: C1.1, C4.1, C6.1, C8.1, C11.1, C14.1, C15.1, C18.1, C21.1, C22.1, C25.1, C28.1, J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, J5.1, J5.2, J6.1, J6.2, J7.1, J7.2, J8.1, J8.2
unnamed: C1.2, J2.3, J2.4, L2.1
unnamed: C2.1, C3.1, L2.2
unnamed: C2.2, C3.2, C4.2, C5.1, C7.1, L3.1
unnamed: C5.2, C6.2, C7.2, J1.3, J1.4, L3.2
unnamed: C8.2, J3.3, J3.4, L1.1
unnamed: C9.1, C10.1, L1.2
unnamed: C9.2, C10.2, C11.2, C12.1, C13.1, L4.1
unnamed: C12.2, C13.2, C14.2, J4.3, J4.4, L4.2
unnamed: C15.2, J5.3, J5.4, L5.1
unnamed: C16.1, C17.1, L5.2
unnamed: C16.2, C17.2, C18.2, C19.1, C20.1, L6.1
unnamed: C19.2, C20.2, C21.2, J6.3, J6.4, L6.2
unnamed: C22.2, J7.3, J7.4, L7.1
unnamed: C23.1, C24.1, L7.2
unnamed: C23.2, C24.2, C25.2, C26.1, C27.1, L8.1
unnamed: C26.2, C27.2, C28.2, J8.3, J8.4, L8.2

Notes on the sheet:
40 M BANDPASS
20 M BANDPASS
80 M BANDPASS

Board: 2 copper layers, 72.4 x 72.4 mm, 74 parts (0 on the bottom side), 17 nets.

Notices in the files:
Code/RFBitBanger/RFBitBanger.ino:
Copyright (c) 2021 Daniel Marks
MatchTester/MatchTester.kicad_pcb:
METER BY KW4TI CC-BY-SA 4.0
