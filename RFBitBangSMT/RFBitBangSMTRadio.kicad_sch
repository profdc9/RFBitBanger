File: RFBitBangSMT/RFBitBangSMTRadio.kicad_sch (KiCad schematic)
At the start: 138 parts, among them J10 si5351mod, J12 Conn_Coaxial, J17 Filt1, J18 Filt2, Q1 MMBT3904, Q10 MMBT3904, Q11 MMBT3904, Q12 MMBT3904, Q13 SS8550, Q15 NC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

Commit message: Added TCXO option to RFBitBanger SMT
Parts:
- added C72: 100 nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol RFBitBangSMT-rescue:C_Small
- added R87: NC, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol RFBitBangSMT-rescue:R
Connections:
- net GND: now also Y3.2, C72.1
- net at C47.2, D14.1 (K), R35.2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: now also R87.2
- net at Y3.4: now also C72.2, R87.1
Other:
- moved on the sheet: D14, R35, Y3

Commit message: Added cut slots around crystal
Parts:
- added H1, H2, H3, H4, H5: MountingHole, RFBitBangSMT:CutSlot, symbol Mechanical:MountingHole
- Y3: footprint Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering -> Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm
Changed lines of the file:
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@@
     (property "Reference" "Y3" (id 0) (at 102.87 61.595 90))
     (property "Value" "25 MHz" (id 1) (at 102.87 59.055 90))
-    (property "Footprint" "Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering" (id 2) (at 101.6 53.34 0)
+    (property "Footprint" "Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm" (id 2) (at 101.6 53.34 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "3")
     (pin "4")
+  )
+  (symbol (lib_id "Mechanical:MountingHole") (at 120.015 83.185 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "H3" (id 0) (at 123.19 81.9149 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (id 1) (at 123.19 84.4549 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "RFBitBangSMT:CutSlot" (id 2) (at 120.015 83.185 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 120.015 83.185 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "RFBitBangSMT-rescue:R") (at 97.155 42.545 180) (unit 1)
@@
     (pin "3")
   )
+  (symbol (lib_id "Mechanical:MountingHole") (at 140.335 83.185 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "H5" (id 0) (at 143.51 81.9149 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (id 1) (at 143.51 84.4549 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "RFBitBangSMT:CutSlot" (id 2) (at 140.335 83.185 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 140.335 83.185 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+  )
   (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 105.41 175.26 90) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "2")
   )
+  (symbol (lib_id "Mechanical:MountingHole") (at 101.6 83.82 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "H1" (id 0) (at 104.775 82.5499 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (id 1) (at 104.775 85.0899 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "RFBitBangSMT:CutSlot" (id 2) (at 101.6 83.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 101.6 83.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+  )
   (symbol (lib_id "Transistor_BJT:MMBT3906") (at 266.7 31.75 0) (mirror x) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "3")
   )
+  (symbol (lib_id "Mechanical:MountingHole") (at 101.6 88.9 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "H2" (id 0) (at 104.775 87.6299 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (id 1) (at 104.775 90.1699 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "RFBitBangSMT:CutSlot" (id 2) (at 101.6 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 101.6 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+  )
+  (symbol (lib_id "Mechanical:MountingHole") (at 120.65 88.9 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "H4" (id 0) (at 123.825 87.6299 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (id 1) (at 123.825 90.1699 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "RFBitBangSMT:CutSlot" (id 2) (at 120.65 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 120.65 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+  )
   (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 24.13 43.18 0) (unit 1)

Commit message: Batch 2 test PCBs
Parts:
- removed C72: 100 nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol RFBitBangSMT-rescue:C_Small
- removed R87: NC, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol RFBitBangSMT-rescue:R
- H1, H2, H3, H4, H5: now left out of the parts list
- R38: LCSC C137549 -> C17521
Connections:
- net GND: no longer Y3.2
Changed lines of the file:
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@@
   (junction (at 201.93 68.58) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 102.87 46.355) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 129.54 182.88) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 33.02 54.61) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 94.615 48.26) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 226.06 59.69) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 96.52 53.34) (xy 96.52 56.515))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 118.11 194.31) (xy 133.985 194.31))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 102.87 46.355) (xy 106.68 46.355))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 180.34 31.75) (xy 179.07 31.75))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 102.87 35.56) (xy 100.965 35.56))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 143.51 55.88) (xy 143.51 54.61))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 102.87 40.005) (xy 102.87 35.56))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 146.05 146.05) (xy 156.21 146.05))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 106.68 46.355) (xy 106.68 53.34))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 43.18 182.88) (xy 43.18 181.61))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 97.155 46.355) (xy 102.87 46.355))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 251.46 151.13) (xy 251.46 149.86))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 94.615 38.735) (xy 97.155 38.735))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 69.85 16.51) (xy 187.96 16.51))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 102.87 45.085) (xy 102.87 46.355))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 215.9 29.21) (xy 215.9 26.67))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 94.615 48.26) (xy 94.615 38.735))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 109.22 57.15) (xy 109.22 63.5))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C137549" (id 4) (at 246.38 43.18 90)
+    (property "LCSC" "C17521" (id 4) (at 246.38 43.18 90)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
   )
   (symbol (lib_id "Mechanical:MountingHole") (at 120.015 83.185 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (in_bom no) (on_board yes) (fields_autoplaced)
     (property "Reference" "H3" (id 0) (at 123.19 81.9149 0)
       (effects (font (size 1.27 1.27)) (justify left))
@@
     )
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:R") (at 97.155 42.545 180) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "R87" (id 0) (at 99.695 42.545 90))
-    (property "Value" "NC" (id 1) (at 97.155 42.545 90))
-    (property "Footprint" "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal" (id 2) (at 98.933 42.545 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 97.155 42.545 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C17710" (id 4) (at 97.155 42.545 90)
-      (effects (font (size 1.524 1.524)) hide)
-    )
-    (pin "1")
-    (pin "2")
-  )
   (symbol (lib_id "Transistor_BJT:MMBT3904") (at 49.53 116.84 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "2")
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 102.87 42.545 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "C72" (id 0) (at 103.124 40.767 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "100 nF" (id 1) (at 99.06 45.085 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 102.87 42.545 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 102.87 42.545 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C49678" (id 4) (at 102.87 42.545 0)
-      (effects (font (size 1.524 1.524)) hide)
-    )
-    (pin "1")
-    (pin "2")
-  )
-  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 100.965 35.56 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR0116" (id 0) (at 100.965 41.91 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (id 1) (at 100.965 39.37 0))
-    (property "Footprint" "" (id 2) (at 100.965 35.56 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 100.965 35.56 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 226.06 31.75 180) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "1")
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 96.52 56.515 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR0115" (id 0) (at 96.52 62.865 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (id 1) (at 96.52 60.325 0))
-    (property "Footprint" "" (id 2) (at 96.52 56.515 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 96.52 56.515 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "RFBitBangSMT-rescue:CP_Small") (at 32.385 173.99 270) (unit 1)
     (in_bom yes) (on_board yes)
@@
   )
   (symbol (lib_id "Mechanical:MountingHole") (at 140.335 83.185 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (in_bom no) (on_board yes) (fields_autoplaced)
     (property "Reference" "H5" (id 0) (at 143.51 81.9149 0)
       (effects (font (size 1.27 1.27)) (justify left))
@@
   )
   (symbol (lib_id "Mechanical:MountingHole") (at 101.6 83.82 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (in_bom no) (on_board yes) (fields_autoplaced)
     (property "Reference" "H1" (id 0) (at 104.775 82.5499 0)
       (effects (font (size 1.27 1.27)) (justify left))
@@
   )
   (symbol (lib_id "Mechanical:MountingHole") (at 101.6 88.9 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (in_bom no) (on_board yes) (fields_autoplaced)
     (property "Reference" "H2" (id 0) (at 104.775 87.6299 0)
       (effects (font (size 1.27 1.27)) (justify left))
@@
   )
   (symbol (lib_id "Mechanical:MountingHole") (at 120.65 88.9 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (in_bom no) (on_board yes) (fields_autoplaced)
     (property "Reference" "H4" (id 0) (at 123.825 87.6299 0)
       (effects (font (size 1.27 1.27)) (justify left))
