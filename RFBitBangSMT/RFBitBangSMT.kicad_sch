File: RFBitBangSMT/RFBitBangSMT.kicad_sch (KiCad schematic)
At the start: 123 parts, among them J1 POWER, J11 AudioJack2_Dual_Ground_Switch, J13 Conn_01x01, J14 Conn_01x01, J15 Conn_01x01, J16 Conn_01x01, J19 AudioJack2_Dual_Ground_Switch, J2 Barrel_Jack, J20 Conn_01x01, J21 Conn_01x01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

Commit message: Added heatsink pad for Q16 RFBitBangSMT
Parts:
- added J23: Conn_01x01, MountingHole:MountingHole_3.2mm_M3, symbol RFBitBangSMT-rescue:Conn_01x01
Changed lines of the file:
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@@
     (pin "2")
+  )
+  (symbol (lib_id "RFBitBangSMT-rescue:Conn_01x01") (at 280.035 149.86 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "J23" (id 0) (at 280.035 147.32 0))
+    (property "Value" "Conn_01x01" (id 1) (at 280.035 152.4 0))
+    (property "Footprint" "MountingHole:MountingHole_3.2mm_M3" (id 2) (at 280.035 149.86 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 280.035 149.86 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
   )
   (symbol (lib_id "RFBitBangSMT-rescue:L") (at 187.325 57.785 270) (unit 1)
@@
       (reference "J22") (unit 1) (value "Conn_01x02") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical")
     )
+    (path "/bf7bf841-e1cd-4d74-b816-09a2f5d77326"
+      (reference "J23") (unit 1) (value "Conn_01x01") (footprint "MountingHole:MountingHole_3.2mm_M3")
+    )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-00006187ae81"

Commit message: Fixed problems with manual, added filters
Parts:
- added C71: NC, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol RFBitBangSMT-rescue:C_Small
Connections:
- net at U3.1: now also C71.1
- net at U3.8: now also C71.2
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 229.87 109.855) (xy 229.87 116.205))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (polyline (pts (xy 113.03 49.53) (xy 113.03 13.97))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 229.87 116.205) (xy 228.6 116.205))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 90.17 186.69) (xy 90.17 185.42))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 223.52 109.855) (xy 229.87 109.855))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 251.46 88.9) (xy 251.46 90.17))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 220.98 116.205) (xy 223.52 116.205))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 41.91 148.59) (xy 24.13 148.59))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 220.98 109.855) (xy 220.98 116.205))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 50.8 40.64) (xy 57.15 40.64))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (pin "2")
   )
+  (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 226.06 116.205 90) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "C71" (id 0) (at 224.282 115.951 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "NC" (id 1) (at 228.6 118.745 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 226.06 116.205 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 226.06 116.205 0))
+    (property "LCSC" "" (id 4) (at 226.06 116.205 0)
+      (effects (font (size 1.524 1.524)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 229.235 40.005 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
       (reference "C70") (unit 1) (value "100 nF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
     )
+    (path "/328edbb5-8b9b-4c59-bc61-9764732eb7b8"
+      (reference "C71") (unit 1) (value "NC") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
+    )
     (path "/00000000-0000-0000-0000-0000615b9029"

Commit message: Manufactured RFBitBangSMT
Parts:
- D1: value 1N4007 -> 1N4745A
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "1000 uF" (id 1) (at 62.484 38.862 0)
+    (property "Value" "1000 uF" (id 1) (at 60.96 31.75 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "D1" (id 0) (at 74.93 36.83 0))
-    (property "Value" "1N4007" (id 1) (at 69.85 36.83 0))
+    (property "Value" "1N4745A" (id 1) (at 72.39 41.91 90))
     (property "Footprint" "Diode_THT:D_DO-41_SOD81_P7.62mm_Horizontal" (id 2) (at 72.39 36.83 0)
       (effects (font (size 1.27 1.27)) hide)
@@
       (reference "#PWR0113") (unit 1) (value "GND") (footprint "")
     )
+    (path "/00000000-0000-0000-0000-000061b53775/64fd2257-0d44-4e05-aa61-6bd43a2184e3"
+      (reference "#PWR0114") (unit 1) (value "GND") (footprint "")
+    )
     (path "/00000000-0000-0000-0000-0000615917e6"
       (reference "C1") (unit 1) (value "100 nF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
@@
       (reference "C48") (unit 1) (value "100 pF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
     )
-    (path "/00000000-0000-0000-0000-000061b53775/6a793429-9796-4cba-9bf8-9842a7016020"
-      (reference "C49") (unit 1) (value "22 uF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
+    (path "/00000000-0000-0000-0000-000061b53775/9054ddf2-3d92-4616-94dc-c8ef24146530"
+      (reference "C49") (unit 1) (value "22 uF") (footprint "Capacitor_THT:CP_Radial_D5.0mm_P2.50mm")
     )
-    (path "/00000000-0000-0000-0000-000061b53775/17c7b7af-e5eb-4134-84d9-0bc2a3fb97a4"
-      (reference "C50") (unit 1) (value "10 uF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
+    (path "/00000000-0000-0000-0000-000061b53775/91ff8ceb-9874-4436-be08-34e2b32bd8ed"
+      (reference "C50") (unit 1) (value "10 uF") (footprint "Capacitor_THT:CP_Radial_D5.0mm_P2.50mm")
     )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-000061b8cd82"
       (reference "C51") (unit 1) (value "100 nF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
     )
-    (path "/00000000-0000-0000-0000-000061b53775/a15d8371-c771-415d-be2c-96d90eae5402"
-      (reference "C52") (unit 1) (value "10 uF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
+    (path "/00000000-0000-0000-0000-000061b53775/44212323-0cc7-4568-aadc-8ff342410e02"
+      (reference "C52") (unit 1) (value "10 uF") (footprint "Capacitor_THT:CP_Radial_D5.0mm_P2.50mm")
     )
     (path "/00000000-0000-0000-0000-000061db14a7"
@@
     )
     (path "/00000000-0000-0000-0000-0000615b9029"
-      (reference "D1") (unit 1) (value "1N4007") (footprint "Diode_THT:D_DO-41_SOD81_P7.62mm_Horizontal")
+      (reference "D1") (unit 1) (value "1N4745A") (footprint "Diode_THT:D_DO-41_SOD81_P7.62mm_Horizontal")
     )
     (path "/00000000-0000-0000-0000-000061593330"
@@
     )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-000061ca9c6d"
-      (reference "D6") (unit 1) (value "D_Zener") (footprint "Diodes_THT:D_DO-41_SOD81_P7.62mm_Horizontal")
+      (reference "D6") (unit 1) (value "1N4757") (footprint "Diodes_THT:D_DO-41_SOD81_P7.62mm_Horizontal")
     )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-00006183d750"
@@
       (reference "JP9") (unit 1) (value "HIGAIN") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical")
     )
+    (path "/00000000-0000-0000-0000-000061b53775/3a169378-d9ee-49a1-b8d5-9f91818468d8"
+      (reference "JP10") (unit 1) (value "BTP") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical")
+    )
     (path "/00000000-0000-0000-0000-0000615a6933"
