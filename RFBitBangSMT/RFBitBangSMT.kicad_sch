File: RFBitBangSMT/RFBitBangSMT.kicad_sch (KiCad schematic)
At the start: 121 parts, among them J1 POWER, J11 AudioJack2_Dual_Ground_Switch, J13 Conn_01x01, J14 Conn_01x01, J15 Conn_01x01, J16 Conn_01x01, J19 AudioJack2_Dual_Ground_Switch, J2 Barrel_Jack, J20 Conn_01x01, J21 Conn_01x01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

Commit message: Some more minor SMT fixed
Parts:
- added R86: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol RFBitBangSMT-rescue:R
Connections:
- net SCK: now also R86.2; no longer R80.1, R82.2
- new net: R80.1, R82.2, R86.1
Other:
- moved on the sheet: C57
Changed lines of the file:
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@@
   (junction (at 261.62 30.48) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 263.525 25.4) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 90.17 158.75) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 242.57 30.48) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 263.525 25.4) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 252.73 60.96) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 263.525 25.4) (xy 264.16 25.4))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 95.25 33.02) (xy 95.25 35.56))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 62.23 134.62) (xy 62.23 132.08))
+  (wire (pts (xy 62.23 133.35) (xy 62.23 132.08))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 42.545 83.82) (xy 42.545 86.36))
+  (wire (pts (xy 42.545 70.485) (xy 42.545 72.39))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 263.525 25.4) (xy 268.605 25.4))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 269.24 52.705) (xy 269.24 60.96))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 42.545 63.5) (xy 42.545 78.74))
+  (wire (pts (xy 42.545 63.5) (xy 42.545 65.405))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 271.78 25.4) (xy 273.05 25.4))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 120.65 180.34) (xy 121.92 180.34))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     )
   )
-  (global_label "SCK" (shape input) (at 268.605 25.4 0) (fields_autoplaced)
+  (global_label "SCK" (shape input) (at 273.05 25.4 0) (fields_autoplaced)
     (effects (font (size 1.524 1.524)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 81.915 82.55 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 86.36 82.55 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 62.23 134.62 0) (unit 1)
+  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 62.23 133.35 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR07" (id 0) (at 62.23 140.97 0)
+    (property "Reference" "#PWR07" (id 0) (at 62.23 139.7 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "GND" (id 1) (at 62.23 138.43 0))
-    (property "Footprint" "" (id 2) (at 62.23 134.62 0)
+    (property "Value" "GND" (id 1) (at 62.23 137.16 0))
+    (property "Footprint" "" (id 2) (at 62.23 133.35 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 62.23 134.62 0)
+    (property "Datasheet" "" (id 3) (at 62.23 133.35 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 42.545 81.28 0) (unit 1)
+  (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 42.545 67.945 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C57" (id 0) (at 42.799 79.502 0)
+    (property "Reference" "C57" (id 0) (at 42.799 66.167 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "100 nF" (id 1) (at 40.005 85.09 90)
+    (property "Value" "100 nF" (id 1) (at 40.005 71.755 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 42.545 81.28 0)
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (id 2) (at 42.545 67.945 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 42.545 81.28 0)
+    (property "Datasheet" "" (id 3) (at 42.545 67.945 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C49678" (id 4) (at 42.545 81.28 0)
+    (property "LCSC" "C49678" (id 4) (at 42.545 67.945 0)
       (effects (font (size 1.524 1.524)) hide)
     )
@@
     (pin "2")
   )
-  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 42.545 86.36 0) (unit 1)
+  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 42.545 72.39 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR047" (id 0) (at 42.545 92.71 0)
+    (property "Reference" "#PWR047" (id 0) (at 42.545 78.74 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "GND" (id 1) (at 42.545 90.17 0))
-    (property "Footprint" "" (id 2) (at 42.545 86.36 0)
+    (property "Value" "GND" (id 1) (at 42.545 76.2 0))
+    (property "Footprint" "" (id 2) (at 42.545 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 42.545 86.36 0)
+    (property "Datasheet" "" (id 3) (at 42.545 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "RFBitBangSMT-rescue:R") (at 267.97 25.4 90) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "R86" (id 0) (at 267.97 23.368 90))
+    (property "Value" "1k" (id 1) (at 267.97 25.4 90))
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (id 2) (at 267.97 27.178 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 267.97 25.4 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C17513" (id 4) (at 267.97 25.4 90)
+      (effects (font (size 1.524 1.524)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "RFBitBangSMT-rescue:R") (at 226.695 62.23 270) (mirror x) (unit 1)
     (in_bom yes) (on_board yes)
@@
       (reference "#PWR093") (unit 1) (value "+5V") (footprint "")
     )
-    (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-000061ba18d8"
-      (reference "#PWR094") (unit 1) (value "+12V") (footprint "")
-    )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-000061bd9d0a"
       (reference "#PWR095") (unit 1) (value "GND") (footprint "")
@@
       (reference "R85") (unit 1) (value "1k") (footprint "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder")
     )
+    (path "/3e13cbed-09a2-4ca3-a1e9-9decef27b9ed"
+      (reference "R86") (unit 1) (value "1k") (footprint "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder")
+    )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-00006183a50a"

Commit message: A few minor fixes to SMT
Parts:
- added J22: Conn_01x02, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x02
- L10: value FB -> 100 uH; footprint Inductor_SMD:L_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> Inductor_THT:L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2
Connections:
- net GND: now also J22.2 (Pin_2)
- net SPKR: now also J22.1 (Pin_1)
Changed lines of the file:
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@@
   (junction (at 229.235 39.37) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 251.46 90.17) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 57.15 40.64) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 251.46 90.17) (xy 255.27 90.17))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 90.17 158.75) (xy 91.44 158.75))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 251.46 90.17) (xy 251.46 102.235))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 24.13 156.21) (xy 31.75 156.21))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 251.46 99.695) (xy 251.46 102.235))
+  (wire (pts (xy 251.46 88.9) (xy 251.46 90.17))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 255.27 92.71) (xy 255.27 94.615))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 242.57 30.48) (xy 245.11 30.48))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     )
   )
-  (global_label "SPKR" (shape input) (at 251.46 99.695 90) (fields_autoplaced)
+  (global_label "SPKR" (shape input) (at 251.46 88.9 90) (fields_autoplaced)
     (effects (font (size 1.524 1.524)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 0 14.605 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 0 3.81 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "L10" (id 0) (at 234.95 103.505 90))
-    (property "Value" "FB" (id 1) (at 234.95 100.33 90))
-    (property "Footprint" "Inductor_SMD:L_0805_2012Metric_Pad1.15x1.40mm_HandSolder" (id 2) (at 234.95 102.235 0)
+    (property "Value" "100 uH" (id 1) (at 234.95 100.33 90))
+    (property "Footprint" "Inductor_THT:L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2" (id 2) (at 234.95 102.235 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "Connector_Generic:Conn_01x02") (at 260.35 90.17 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "J22" (id 0) (at 262.89 90.1699 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Conn_01x02" (id 1) (at 262.89 92.7099 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 260.35 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 260.35 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "MCU_Microchip_ATmega:ATmega328P-A") (at 62.23 93.98 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "2")
   )
+  (symbol (lib_id "RFBitBangSMT-rescue:GND") (at 255.27 94.615 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR0113" (id 0) (at 255.27 100.965 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 255.27 98.425 0))
+    (property "Footprint" "" (id 2) (at 255.27 94.615 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 255.27 94.615 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "RFBitBangSMT-rescue:C_Small") (at 227.33 67.31 90) (unit 1)
     (in_bom yes) (on_board yes)
@@
       (reference "#PWR0112") (unit 1) (value "GND") (footprint "")
     )
+    (path "/8e3eb73a-f592-4b46-83c9-7e804d91259c"
+      (reference "#PWR0113") (unit 1) (value "GND") (footprint "")
+    )
     (path "/00000000-0000-0000-0000-0000615917e6"
       (reference "C1") (unit 1) (value "100 nF") (footprint "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder")
@@
       (reference "J21") (unit 1) (value "Conn_01x01") (footprint "Connectors:1pin")
     )
+    (path "/20dea924-489b-4047-baef-229a89a54746"
+      (reference "J22") (unit 1) (value "Conn_01x02") (footprint "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical")
+    )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-00006187ae81"
       (reference "JP1") (unit 1) (value "QSK") (footprint "Pin_Headers:Pin_Header_Straight_1x02_Pitch2.54mm")
@@
     )
     (path "/00000000-0000-0000-0000-000061db2b24"
-      (reference "L10") (unit 1) (value "FB") (footprint "Inductor_SMD:L_0805_2012Metric_Pad1.15x1.40mm_HandSolder")
+      (reference "L10") (unit 1) (value "100 uH") (footprint "Inductor_THT:L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2")
     )
     (path "/00000000-0000-0000-0000-000061b53775/00000000-0000-0000-0000-000061c8d7a8"
